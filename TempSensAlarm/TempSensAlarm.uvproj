# Keil uVision project TempSensAlarm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: TempSensAlarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC=22118400 EEPROM_WRITE DEBUG
  c include: ../TempSensSender
  group Source Group 1
    ../TempSensSender/: uart.c EEPROM.c misc.c Timer.c
    ./: main.c esp8266.c
  group Headers
    ./: esp8266.h
    ../TempSensSender/: misc.h uart.h Timer.h EEPROM.h
